# Keil uVision project libhal_core_CM4_Keil.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MT7686D MediaTek
  pack: MediaTek.MTx.4.3.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libhal_core_CM4_Keil (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c misc: --c99
  c include: ..\..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include;..\..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\..\kernel\service\inc;..\..\..\..\..\..\kernel\service\syslog\inc;..\..\..\..\..\..\driver\chip\inc;..\..\..\..\..\..\driver\chip\mt7686\inc;..\..\..\..\..\..\driver\chip\mt7686\src\common\include;..\..\..\common\inc;.\inc;..\..\..\..\..\..\middleware\MTK\minicli\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
  group driver
    ../../: hal_efuse.c hal_sleep_manager.c hal_sleep_manager_internal.c hal_spm.c
