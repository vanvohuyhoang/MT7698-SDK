# IAR project libhal_core_CM4_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: inc; ..\..\inc; ..\..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\..\kernel\service\syslog\inc; ..\..\..\..\..\..\middleware\MTK\connsys\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: libhal_core_CM4_IAR.bin
  ILINK.IlinkOutputFile: adc_get_data_polling.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group driver
    ../../: hal_efuse.c hal_sleep_driver.c hal_sleep_manager.c
